File: 1st iteration/E-GPS/irisc.brd (EAGLE design)
At the start: 44.9 x 30.1 mm, 5 parts

Commit message: E's systems almost done (only PCB gyro missing)
Routing:
- net 0: track 29.4 -> 86.6 mm
